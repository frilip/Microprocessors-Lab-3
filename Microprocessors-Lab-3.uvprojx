# Keil uVision project Microprocessors-Lab-3.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart_read_write_prjct
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: .\drivers
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group main_group
    ./: main.c
  group drivers
    ./drivers/: adc.c adc.h comparator.c comparator.h gpio.c gpio.h i2c.c i2c.h leds.c leds.h platform.h stm32f4xx_rcc.c queue.c queue.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_rcc.h stm32f4xx_usart.c stm32f4xx_usart.h timer.c timer.h uart.c uart.h delay.c delay.h delay_as.s
  group DHT11
    ./: driver_dht11.h driver_dht11.c driver_dht11_basic.c driver_dht11_basic.h driver_dht11_interface.h driver_dht11_interface_template.c DHT11_custom.c DHT11_custom.h
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
